# Keil uVision project gd32f407_bootloader.uvprojx, settings and files
target gd32f407_bootloader (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F407ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.5
  cpu: IRAM(0x20000000,0x00030000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") CLOCK(25000000) ELITTLE FPU2
  output: gd32f407_bootloader_OUTPUT +hex
  AfterMake: fromelf --bin --output "$L\gd32f407_bootloader_OUTPUT.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F407,CHIP_SERIES_F407,USE_STDPERIPH_DRIVER
  c include: ..\..\f407_upgrade_gd\Libraries\CMSIS\GD\GD32F4xx\Include;..\..\f407_upgrade_gd\Libraries\CMSIS;..\..\f407_upgrade_gd\Libraries\GD32F4xx_standard_peripheral\Include;..\Source\Main;..\Source\Dev
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group StartUp
    ../../f407_upgrade_gd/Libraries/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group CMSIS
    ../../f407_upgrade_gd/Libraries/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Peripherals
    ../../f407_upgrade_gd/Libraries/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_usart.c gd32f4xx_timer.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_fmc.c
  group Main
    ../Source/Main/: main.c gd32f4xx_libopt.h config.h chip_select.h platform.h system.c system.h
    ../Source/Dev/: upgrade_config.h
  group Dev
    ../Source/Dev/: Delay.c Delay.h RemapGPIO.h usart.c usart.h TIM2.c TIM2.h spi_flash.c spi_flash.h md5.c md5.h
