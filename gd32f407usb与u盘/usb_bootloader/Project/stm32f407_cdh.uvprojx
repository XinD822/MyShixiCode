# Keil uVision project stm32f407_cdh.uvprojx, settings and files
target stm32f407_cdh (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: stm32f407_cdh_OUTPUT +hex
  AfterMake: fromelf --bin --output "$L\stm32f407_cdh_OUTPUT.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,CHIP_SERIES_F407
  c include: ..\..\f407_upgrade\CORE;..\..\f407_upgrade\USER;..\..\f407_upgrade\FWLIB\inc;..\Source\Main;..\Source\Dev
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ../../f407_upgrade/CORE/: startup_stm32f40_41xxx.s
  group CMSIS
    ../../f407_upgrade/CORE/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cm4_simd.h
    ../../f407_upgrade/USER/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group FWlib
    ../../f407_upgrade/FWLIB/src/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Main
    ../Source/Main/: main.c stm32f4xx_conf.h config.h chip_select.h platform.h system.c system.h
  group Dev
    ../Source/Dev/: Delay.c Delay.h RemapGPIO.h usart.c usart.h TIM2.c TIM2.h spi_flash.c spi_flash.h fatfs_system.h
