# Keil uVision project KEY.uvprojx, settings and files
target KEY (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08010000,0x70000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: KEY +hex
  AfterMake: fromelf --bin --output "$L\KEY_OUTPUT.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\FWLIB\inc;..\usb_upgrade\bsp;..\usb_upgrade\inc;..\usb_upgrade\src;..\usb_upgrade\middleware;..\usb_upgrade\middleware\FatFS;..\usb_upgrade\usb_app;..\usb_upgrade\usb_lib\core\inc;..\usb_upgrade\usb_lib\msc\inc;..\usb_upgrade\usb_lib\otg\inc;..\usb_upgrade\usb_lib\host\core\inc;..\usb_upgrade\usb_lib\host\msc\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group usb_upgrade/src
    ../usb_upgrade/src/: fatfs_system.c firmware_check.c flash_service.c source_usb_drag.c upgrade.c upgrade_source.c usb_mode.c usb_task.c usb_upgrade.c source_usb_host.c usb_host_task.c
  group usb_upgrade/bsp
    ../usb_upgrade/bsp/: w25q128_drv.c tick_drv.c debug_uart.c platform.c board_config.h
  group usb_upgrade/fatfs
    ../usb_upgrade/middleware/FatFS/: diskio.c ff.c ffsystem.c ffunicode.c
  group usb_upgrade/usb_app
    ../usb_upgrade/usb_app/: usb_bsp.c usb_msc_device.c usbd_desc.c usbd_storage_msd.c usbd_usr.c usbh_usr.c
  group usb_upgrade/usb_lib
    ../usb_upgrade/usb_lib/otg/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_otg.c usb_hcd.c usb_hcd_int.c
    ../usb_upgrade/usb_lib/core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../usb_upgrade/usb_lib/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
    ../usb_upgrade/usb_lib/host/core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../usb_upgrade/usb_lib/host/msc/src/: usbh_msc_core.c usbh_msc_bot.c usbh_msc_scsi.c
