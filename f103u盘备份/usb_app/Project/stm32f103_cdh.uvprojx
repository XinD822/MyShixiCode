# Keil uVision project stm32f103_cdh.uvprojx, settings and files
target stm32f103_cdh (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08010000,0x00070000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103_cdh_OUTPUT +hex
  AfterMake: fromelf --bin --output "$L\stm32f103_cdh_OUTPUT.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\Source\Main;..\Source\Dev;..\Source\Dev\Mass_Storage\src_inc;..\Source\Dev\STM32_USB-FS-Device_Driver\src_inc;..\Source\Dev\FatFs;..\Source\Dev\CherryUSB;..\Source\Dev\CherryUSB\class;..\Source\Dev\CherryUSB\commom;..\Source\Dev\CherryUSB\core;..\Source\Dev\CherryUSB\port
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWlib
    ../Libraries/FWlib/src/: misc.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Main
    ../Source/Main/: main.c stm32f10x_conf.h stm32f10x_it.c config.h system.c system.h readme.txt
  group Dev
    ../Source/Dev/: Delay.c Delay.h RemapGPIO.h usart.c usart.h TIM2.c TIM2.h spi_flash.c spi_flash.h fatfs_system.c fatfs_system.h firmware_check.c upgrade.c error_handler.c mutex.c LED.c sys.c
  group FatFs
    ../Source/Dev/FatFs/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
  group CherryUSB
    ../Source/Dev/CherryUSB/class/: usb_msc.h usb_scsi.h usbd_msc.c usbd_msc.h
    ../Source/Dev/CherryUSB/commom/: usb_dc.h usb_dcache.h usb_def.h usb_errno.h usb_list.h usb_log.h usb_memcpy.h usb_mempool.h usb_osal.h usb_ringbuffer.h usb_util.h usb_version.h
    ../Source/Dev/CherryUSB/core/: usbd_core.c usbd_core.h
    ../Source/Dev/CherryUSB/port/: usb_dc_fsdev.c usb_fsdev_reg.h usb_glue_st.c
    ../Source/Dev/CherryUSB/: usb_msc_device.c mass_mal.c
