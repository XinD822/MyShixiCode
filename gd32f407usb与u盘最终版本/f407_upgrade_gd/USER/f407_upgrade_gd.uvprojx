# Keil uVision project f407_upgrade_gd.uvprojx, settings and files
target f407_upgrade_gd (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F407ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.5
  cpu: IRAM(0x20000000,0x00030000) IROM(0x08010000,0x00070000) CPUTYPE("Cortex-M4") CLOCK(168000000) ELITTLE FPU2
  output: f407_upgrade_gd +hex
  AfterMake: fromelf --bin --output "$L\f407_upgrade_gd_OUTPUT.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F407
  c include: .\;.\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\BEEP;..\Libraries\CMSIS\GD\GD32F4xx\Include;..\Libraries\CMSIS;..\Libraries\GD32F4xx_standard_peripheral\Include;..\Libraries\GD32F4xx_usb_library\driver\Include;..\Libraries\GD32F4xx_usb_library\device\core\Include;..\Libraries\GD32F4xx_usb_library\device\class\msc\Include;..\Libraries\GD32F4xx_usb_library\ustd\common;..\Libraries\GD32F4xx_usb_library\ustd\class\msc;..\Libraries\GD32F4xx_usb_library\host\core\Include;..\Libraries\GD32F4xx_usb_library\host\class\msc\Include;..\usb_upgrade\bsp;..\usb_upgrade\plat;..\usb_upgrade\inc;..\usb_upgrade\src;..\usb_upgrade\middleware;..\usb_upgrade\middleware\FatFS;..\usb_upgrade\usb_app
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group USER
    ./: main.c gd32f4xx_it.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
  group CMSIS
    ../Libraries/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Peripherals
    ../Libraries/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_usart.c gd32f4xx_timer.c gd32f4xx_misc.c gd32f4xx_pmu.c
  group Startup
    ../Libraries/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group usb_upgrade/src
    ../usb_upgrade/src/: fatfs_system.c firmware_check.c flash_service.c source_usb_drag.c source_usb_host.c upgrade.c md5.c upgrade_source.c usb_mode.c usb_task.c usb_upgrade.c usb_host_task.c
  group usb_upgrade/bsp
    ../usb_upgrade/bsp/: w25q128_drv.c plat_flash_w25q128.c plat_tick_internal.c plat_tick_external.c plat_log_uart.c plat_reset_gd32.c plat_button_gd32.c plat_timer.c
  group usb_upgrade/fatfs
    ../usb_upgrade/middleware/FatFS/: diskio.c ff.c ffsystem.c ffunicode.c
  group usb_upgrade/usb_app
    ../usb_upgrade/usb_app/: usb_hw.c usb_msc_device.c usbd_storage_msd.c usbh_usr.c
  group usb_lib/driver
    ../Libraries/GD32F4xx_usb_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c drv_usb_host.c drv_usbh_int.c
  group usb_lib/device-core
    ../Libraries/GD32F4xx_usb_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group usb_lib/msc
    ../Libraries/GD32F4xx_usb_library/device/class/msc/Source/: usbd_msc_core.c usbd_msc_bbb.c usbd_msc_scsi.c
  group usb_lib/host-core
    ../Libraries/GD32F4xx_usb_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group usb_lib/host-msc
    ../Libraries/GD32F4xx_usb_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_scsi.c
